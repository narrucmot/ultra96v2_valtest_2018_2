SRC_URI += "file://user_ULTRA96V2.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
